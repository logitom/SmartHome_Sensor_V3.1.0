# Keil uVision project Project.uvprojx, settings and files
target S2LP_STM32F401RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Spirit1_Point-To-Point
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32F4XX_NUCLEO,USE_STDPERIPH_DRIVER,STM32F4,USE_HAL_DRIVER,STM32F401xE,USE_SYSTICK_DELAY,S2LP_SUPPORT,X_NUCLEO_S2868A1,USE_SPIRIT1_DEFAULT
  c include: ../../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Inc;../../../../../../Drivers/BSP/STM32F4xx_Nucleo;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Driver/BSP/Components/S2LP/S2LP_Util
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Application/USER
    ../../Src/: main.c stm32f4xx_it.c cube_hal_f4.c s2lp_interface.c radio_appli.c
  group Driver/BSP/Components/SPIRIT1/Spirit1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Radio.c SPIRIT_LinearFifo.c SPIRIT_PktCommon.c SPIRIT_Commands.c SPIRIT_Timer.c SPIRIT_PktBasic.c SPIRIT_Gpio.c SPIRIT_Csma.c SPIRIT_General.c SPIRIT_PktMbus.c SPIRIT_Irq.c SPIRIT_PktStack.c SPIRIT_DirectRF.c SPIRIT_Calibration.c SPIRIT_Types.c SPIRIT_Aes.c SPIRIT_Qi.c SPIRIT_Management.c
  group Driver/BSP/Components/SPIRIT1/Spirit1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Driver/BSP/Components/S2LP/S2LP_Library
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Fifo.c S2LP_General.c S2LP_PktStack.c S2LP_PacketHandler.c S2LP_Radio.c S2LP_Timer.c S2LP_PktBasic.c S2LP_Commands.c S2LP_Timer_ex.c S2LP_PktWMbus.c S2LP_Gpio.c S2LP_Types.c S2LP_Csma.c S2LP_Qi.c
  group Driver/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_qspi.c stm32f4xx_hal_spdifrx.c stm32f4xx_ll_usart.c stm32f4xx_ll_exti.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_rng.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_nand.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_lptim.c stm32f4xx_hal_crc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_rcc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_cec.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_mmc.c stm32f4xx_ll_i2c.c stm32f4xx_ll_pwr.c stm32f4xx_ll_gpio.c stm32f4xx_hal_smartcard.c stm32f4xx_ll_crc.c stm32f4xx_hal_irda.c stm32f4xx_hal_dsi.c stm32f4xx_ll_adc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_rng.c stm32f4xx_hal_sai.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_hash.c stm32f4xx_ll_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_usart.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_tim.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_lptim.c stm32f4xx_ll_spi.c stm32f4xx_ll_utils.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_dac.c stm32f4xx_hal_dma2d.c stm32f4xx_hal.c
  group Driver/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_spi.c radio_shield_config.c radio_gpio.c
  group Doc
    ../../: readme.txt
  group Driver/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Driver/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_gpio.c radio_timer.c radio_eeprom.c radio_spi.c radio_shield_config.c
  group Driver/BSP/STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
target SPIRIT1_STM32F401RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: as above
  output: Spirit1_Point-To-Point
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,STM32F401xE,P2P_DEMO,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT,STM32F4,NO_EEPROM,X_NUCLEO_IDS01A4,USE_STDPERIPH_DRIVER,USE_SYSTICK_DELAY
  c include: ../../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../Drivers/BSP/STM32F4xx_Nucleo;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 4.3.0
