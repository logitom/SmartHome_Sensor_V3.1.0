# Keil uVision project Project.uvprojx, settings and files
target SPIRIT1_STM32L152RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: S2LP_Point-To-Point
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER,STM32L152xE,P2P_DEMO,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT,STM32L1,NO_EEPROM,X_NUCLEO_IDS01A4,USE_STDPERIPH_DRIVER,USE_SYSTICK_DELAY
  c include: ../../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Driver/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_spi.c radio_gpio.c radio_shield_config.c
  group Application/USER
    ../../Src/: radio_appli.c main.c s2lp_interface.c stm32l1xx_it.c cube_hal_l1.c
  group Driver/BSP/Components/S2LP/S2LP_Library
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Gpio.c S2LP_General.c S2LP_PacketHandler.c S2LP_Fifo.c S2LP_Csma.c S2LP_PktStack.c S2LP_Timer.c S2LP_PktBasic.c S2LP_PktWMbus.c S2LP_Timer_ex.c S2LP_Qi.c S2LP_Commands.c S2LP_Types.c S2LP_Radio.c
  group Driver/CMSIS
    ../../Src/: system_stm32l1xx.c
  group Driver/BSP/Components/S2LP/S2LP_Util
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Driver/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Driver/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_timer.c radio_gpio.c radio_spi.c radio_shield_config.c radio_eeprom.c
  group Doc
    ../../: readme.txt
  group Driver/BSP/Components/SPIRIT1/spirit1_library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Types.c SPIRIT_Irq.c SPIRIT_Timer.c SPIRIT_Csma.c SPIRIT_Aes.c SPIRIT_Gpio.c SPIRIT_Management.c SPIRIT_Commands.c SPIRIT_Calibration.c SPIRIT_LinearFifo.c SPIRIT_General.c SPIRIT_PktBasic.c SPIRIT_Qi.c SPIRIT_PktMbus.c SPIRIT_PktCommon.c SPIRIT_Radio.c SPIRIT_DirectRF.c SPIRIT_PktStack.c
  group Driver/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash.c stm32l1xx_hal_irda.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_adc.c stm32l1xx_hal_cortex.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_i2s.c stm32l1xx_hal_crc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_rcc.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal.c stm32l1xx_hal_tim.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_lcd.c stm32l1xx_hal_comp.c stm32l1xx_hal_dac.c
  group Driver/BSP/Components/SPIRIT1/Spirit1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
target S2LP_STM32L152RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: S2LP_Point-To-Point
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32L1XX_NUCLEO,USE_STDPERIPH_DRIVER,STM32L1,USE_HAL_DRIVER,STM32L152xE,USE_SYSTICK_DELAY,S2LP_SUPPORT,X_NUCLEO_S2868A1,USE_SPIRIT1_DEFAULT
  c include: ../../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Inc;../../../../../../Drivers/BSP/Components/;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
software components: CMSIS:CORE 4.3.0
