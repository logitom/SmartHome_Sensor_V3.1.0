# Keil uVision project Project.uvprojx, settings and files
target SPIRIT1-Meter-868MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_Nucleo_WMBus
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32L1XX_NUCLEO,STM32L152xx,STM32L152xE,NO_EEPROM,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT,STM32L1,X_NUCLEO_IDS01A4,USE_WMBUS
  c include: ../../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc;../../../../../../Middlewares/ST/WMBUS_Library_2013 ;../../../../../../Middlewares/ST/WMBUS_Library_2013/phy/inc ;../../../../../../Middlewares/ST/WMBUS_Library_2013/link/inc;../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/inc;../../../../../../Middlewares/ST/WMBUS_Library/RF_hal/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/User
    ../../Src/: radio_hal.c cube_hal_l1.c main.c wmbus_tim.c stm32l1xx_it.c
  group Application/Command
    ../../Src/: cmd_crc.c command.c fifo.c uart.c user_appli.c
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Middlewares/WMBUS_Library/Library
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/Library/: SPIRIT1_wMBus_Library242_CM3_Keil.lib S2LP_wMBus_Library250_CM3_wc32_Ob.a
  group Middlewares/WMBUS_Library/Appli
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/src/: wmbus_cbc.c aes.c
  group Middlewares/WMBUS_Library/Link
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/link/src/: wmbus_linkcommand.c wmbus_crc.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/Components/spirit1/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Gpio.c SPIRIT_Radio.c SPIRIT_Types.c SPIRIT_LinearFifo.c SPIRIT_PktStack.c SPIRIT_Commands.c SPIRIT_PktMbus.c SPIRIT_General.c SPIRIT_PktBasic.c SPIRIT_Management.c SPIRIT_DirectRF.c SPIRIT_Calibration.c SPIRIT_Irq.c SPIRIT_PktCommon.c SPIRIT_Csma.c SPIRIT_Qi.c SPIRIT_Timer.c SPIRIT_Aes.c
  group Drivers/BSP/Components/spirit1/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/BSP/Components/S2-LP/S2LP_UTILS
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Drivers/BSP/Components/S2-LP/S2LP_LIB
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Gpio.c S2LP_Csma.c S2LP_PktStack.c S2LP_General.c S2LP_Fifo.c S2LP_Radio.c S2LP_PktBasic.c S2LP_Timer_ex.c S2LP_PktWMbus.c S2LP_Timer.c S2LP_Commands.c S2LP_Qi.c S2LP_Types.c S2LP_PacketHandler.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_eeprom.c radio_gpio.c radio_shield_config.c radio_spi.c radio_timer.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_gpio.c stm32l1xx_hal_usart.c stm32l1xx_hal_rcc.c stm32l1xx_hal_adc.c stm32l1xx_hal_crc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_uart.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal.c stm32l1xx_hal_cortex.c
  group Doc
    ../../: readme.txt
target S2LP-Meter-868Mhz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_Nucleo_WMBus
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32L1XX_NUCLEO,STM32L152xx,STM32L152xE,NO_EEPROM,USE_S2_LP_DEFAULT,DEVICE_TYPE_METER,STM32L1,ENABLE_VCOM,USE_SYSTICK_DELAY,USE_WMBUS
  c misc: --wchar32
  c include: ../../Inc;../../Commands/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers\BSP\X-NUCLEO-S2868A1\Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../Drivers\BSP\Components\S2LP\S2LP_Util\Inc;../../../../../../Middlewares/ST/WMBUS_Library_2013 ;../../../../../../Middlewares/ST/WMBUS_Library_2013/phy/inc ;../../../../../../Middlewares/ST/WMBUS_Library_2013/link/inc;../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/inc;../../../../../../Middlewares/ST/WMBUS_Library/RF_hal/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
software components: CMSIS:CORE 4.3.0
