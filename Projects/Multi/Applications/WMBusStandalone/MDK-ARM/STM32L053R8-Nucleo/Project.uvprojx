# Keil uVision project Project.uvprojx, settings and files
target SPIRIT1-Meter-868MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32_Nucleo_WMBus
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32L0XX_NUCLEO,STM32L053xx,NO_EEPROM,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT,STM32L0,X_NUCLEO_IDS01A4,USE_WMBUS
  c include: ../../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc;../../../../../../Middlewares/ST/WMBUS_Library_2013 ;../../../../../../Middlewares/ST/WMBUS_Library_2013/phy/inc ;../../../../../../Middlewares/ST/WMBUS_Library_2013/link/inc;../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/User
    ../../Src/: cube_hal_l0.c radio_hal.c stm32l0xx_it.c main.c wmbus_tim.c
  group Application/Command
    ../../Src/: cmd_crc.c command.c fifo.c uart.c user_appli.c
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Middlewares/wMBus_Library/Appli
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/src/: aes.c wmbus_cbc.c
  group Middlewares/wMBus_Library/Library
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/Library/: SPIRIT1_wMBus_Library242_CM0_Keil.lib S2LP_wMBus_Library250_CM0_wc32_Ob.a
  group Middlewares/wMBus_Library/Link
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/link/src/: wmbus_crc.c wmbus_linkcommand.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_PktMbus.c SPIRIT_Csma.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_PktBasic.c SPIRIT_Radio.c SPIRIT_Aes.c SPIRIT_Commands.c SPIRIT_Calibration.c SPIRIT_DirectRF.c SPIRIT_Management.c SPIRIT_Qi.c SPIRIT_Timer.c SPIRIT_General.c SPIRIT_PktStack.c SPIRIT_PktCommon.c SPIRIT_Gpio.c SPIRIT_Types.c
  group Drivers/BSP/Component/S2-LP/S2LP_UTILS
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Drivers/BSP/Component/S2-LP/S2LP_LIB
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_PacketHandler.c S2LP_Commands.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_General.c S2LP_Fifo.c S2LP_Timer_ex.c S2LP_Types.c S2LP_Timer.c S2LP_Gpio.c S2LP_PktStack.c S2LP_PktBasic.c S2LP_Csma.c S2LP_Radio.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_spi.c radio_gpio.c radio_shield_config.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_eeprom.c radio_gpio.c radio_shield_config.c radio_spi.c radio_timer.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_spi.c stm32l0xx_hal_rcc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_adc.c stm32l0xx_hal_uart.c stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Doc
    ../../: readme.txt
target S2LP-Meter-868MHz (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: STM32_Nucleo_WMBus
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32L0XX_NUCLEO,STM32L053xx,NO_EEPROM,USE_S2_LP_DEFAULT,DEVICE_TYPE_METER,STM32L0,ENABLE_VCOM,USE_SYSTICK_DELAY,USE_WMBUS
  c misc: --wchar32
  c include: ../../Inc;../../Commands/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers\BSP\X-NUCLEO-S2868A1\Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../Drivers\BSP\Components\S2LP\S2LP_Util\Inc;../../../../../../Middlewares/ST/WMBUS_Library_2013;../../../../../../Middlewares/ST/WMBUS_Library_2013/phy/inc;../../../../../../Middlewares/ST/WMBUS_Library_2013/link/inc;../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 4.3.0
