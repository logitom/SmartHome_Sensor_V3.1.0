# IAR project STM32_Nucleo_WMBus.ewp, settings and files
configuration SPIRIT1-Meter-868MHz (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO; STM32F401xE; NO_EEPROM; SPIRIT1_ST_SHIELD; USE_SPIRIT1_DEFAULT; STM32F4; X_NUCLEO_IDS01A4; USE_WMBUS
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\phy\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\link\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\AES_Encr\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_Nucleo_WMBus.bin
  ILINK.IlinkOutputFile: STM32_Nucleo_WMBus.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S2LP-Meter-868MHz (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO; STM32F401xE; NO_EEPROM; ENABLE_VCOM; USE_S2_LP_DEFAULT; DEVICE_TYPE_METER; STM32F4; USE_WMBUS; USE_SYSTICK_DELAY
  ICCARM.IExtraOptions: --aeabi; --guard_calls
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Commands\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-S2868A1\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\S2LP\S2LP_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\S2LP\S2LP_Util\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\phy\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\link\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\AES_Encr\inc
  group Application/Command
    ../../Src/: cmd_crc.c command.c fifo.c uart.c user_appli.c
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../../Src/: cube_hal_f4.c main.c radio_hal.c stm32f4xx_it.c wmbus_tim.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Component/S2-LP/S2LP-UTILS
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Drivers/BSP/Component/S2-LP/S2LP_LIB
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_eeprom.c radio_gpio.c radio_shield_config.c radio_spi.c radio_timer.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c
  group Middlewares/wMBus_Library/Appli
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/src/: aes.c wmbus_cbc.c
  group Middlewares/wMBus_Library/Library
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/Library/: S2LP_wMBus_Library250_CM4_wc32_Ob.a SPIRIT1_wMBus_Library242_CM4_IAR.a
  group Middlewares/wMBus_Library/Link
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/link/src/: wmbus_crc.c wmbus_linkcommand.c
