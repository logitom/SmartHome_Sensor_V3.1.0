# IAR project STM32_Nucleo_WMBus.ewp, settings and files
configuration SPIRIT1-Meter-868MHz (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM32L0XX_NUCLEO; STM32L053xx; NO_EEPROM; SPIRIT1_ST_SHIELD; USE_SPIRIT1_DEFAULT; STM32L0; X_NUCLEO_IDS01A4
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\phy\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\link\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\AES_Encr\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_Nucleo_WMBus.bin
  ILINK.IlinkOutputFile: STM32_Nucleo_WMBus.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S2LP-Meter-868MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM32L0XX_NUCLEO; STM32L053xx; NO_EEPROM; USE_S2_LP_DEFAULT; DEVICE_TYPE_METER; STM32L0; ENABLE_VCOM; USE_WMBUS; USE_SYSTICK_DELAY
  ICCARM.IExtraOptions: --aeabi; --guard_calls
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Commands\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-S2868A1\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\S2LP\S2LP_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\S2LP\S2LP_Util\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\phy\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\link\inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\AES_Encr\inc
  group Application/Command
    ../../Src/: cmd_crc.c command.c fifo.c uart.c user_appli.c
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../../Src/: cube_hal_l0.c main.c radio_hal.c stm32l0xx_it.c wmbus_tim.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Component/S2-LP/S2LP_LIB
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/Component/S2-LP/S2LP_UTILS
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_eeprom.c radio_gpio.c radio_shield_config.c radio_spi.c radio_timer.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/wMBus_Library/Appli
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/src/: aes.c wmbus_cbc.c
  group Middlewares/wMBus_Library/Library
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/Library/: S2LP_wMBus_Library250_CM0_wc32_Ob_1.a SPIRIT1_wMBus_Library242_CM0_IAR.a
  group Middlewares/wMBus_Library/Link
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/link/src/: wmbus_crc.c wmbus_linkcommand.c
