# IAR project Project.ewp, settings and files
configuration SPIRIT1_STM32L152RE_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: X_NUCLEO_IDS01A4; MCU_LOW_POWER=0; RADIO_LOW_POWER=0; PROJECT_CONF_H=1; STM32L152xE; USE_USART2; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; HSE_VALUE=84000000ul; USE_STDPERIPH_DRIVER; USE_SPIRIT1_DEFAULT; WITH_UIP6=1; IAR_ARM_CM3; VECT_TAB_FLASH; WITH_UIP; WITH_ASCII; CONTIKI=1; UIP_CONF_TCP=1; NETSTACK_CONF_WITH_IPV6=1; UIP_CONF_IPV6_RPL=1; AUTOSTART_ENABLE=1; NO_EEPROM; SPIRIT1_ST_SHIELD; SPIRIT_MODULE; AUTOSTART_ENABLE; SERIAL_SNIFFER
  ICCARM.IExtraOptions: --diag_suppress=Pa089; --diag_suppress=Pe188
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library; ..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc; ..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev; ..\..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\servreg-hack; ..\..\..\..\..\..\..\Projects\Multi\Applications\Contiki\Serial-sniffer\Inc; ..\..\..\..\..\..\..\Projects\Multi\Applications\Contiki\Serial-sniffer\Src\sniffer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Serial-sniffer_l152.bin
  ILINK.IlinkOutputFile: Serial-sniffer_l152.out
  ILINK.IlinkIcfFile: stm32L152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S2LP_STM32L152RE_Nucleo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: X_NUCLEO_S2868A1; MCU_LOW_POWER=0; RADIO_LOW_POWER=0; RADIO_USES_LONG_PREAMBLE=1; PROJECT_CONF_H=1; STM32L152xE; USE_USART2; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; USE_STDPERIPH_DRIVER; USE_SPIRIT1_DEFAULT; WITH_UIP6=1; IAR_ARM_CM3; CONTIKI=1; UIP_CONF_TCP=1; NETSTACK_CONF_WITH_IPV6; UIP_CONF_IPV6_RPL=1; AUTOSTART_ENABLE; USE_SYSTICK_DELAY; HSE_VALUE=32000000ul; WITH_UIP; NETSTACK_CONF_WITH_IPV6=1; AUTOSTART_ENABLE=1; SERIAL_SNIFFER; PROJECT_CONF_H=\"project-conf.h\"; NETSTACK_CONF_WITH_RIME
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-S2868A1\Inc; ..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library; ..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc; ..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev; ..\..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\..\Drivers\BSP\Components\S2LP\S2LP_Library\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\S2LP\S2LP_Util\Inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib; ..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\servreg-hack; ..\..\..\..\..\..\..\Projects\Multi\Applications\Contiki\Serial-sniffer\Inc; ..\..\..\..\..\..\..\Projects\Multi\Applications\Contiki\Serial-sniffer\Src\sniffer
  group Drivers/BSP/Components/S2LP/S2LP_Library
    ../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Types.c
  group Drivers/BSP/Components/S2LP/S2LP_Util
    ../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Drivers/BSP/Components/SPIRIT1
    ../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32L1xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_eeprom.c radio_gpio.c radio_shield_config.c radio_spi.c radio_timer.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group Example/EWARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../../Src/: cube_hal_l1.c main.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Example/User/sniffer
    ../../Src/sniffer/: framer-sniffer-802154.c serial-sniffer.c sniffer.c
  group Middlewares/Contiki/apps/servreg-hack
    ../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack/: servreg-hack.c
  group Middlewares/Contiki/core/dev
    ../../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c slip.c
  group Middlewares/Contiki/core/lib
    ../../../../../../../Middlewares/Third_Party/Contiki/core/lib/: list.c memb.c random.c sensors.c
  group Middlewares/Contiki/core/net
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nordc.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/Contiki/core/sys
    ../../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: button-sensor.c leds-arch.c radio-sensor.c
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-st-radio-main.c node-id.c radio-arch.c radio-driver.c rtimer-arch.c uart-msg.c watchdog.c
