# Keil uVision project Project.uvprojx, settings and files
target S2LP_STM32F401RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Serial-sniffer_f401
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: X_NUCLEO_S2868A1,MCU_LOW_POWER=0,RADIO_LOW_POWER=0,PROJECT_CONF_H=1,STM32F401xE,USE_USART2,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,HSE_VALUE=84000000ul,USE_STDPERIPH_DRIVER,USE_SPIRIT1_DEFAULT,WITH_UIP6=1,IAR_ARM_CM3,VECT_TAB_FLASH,WITH_UIP,WITH_ASCII,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,USE_SYSTICK_DELAY,SERIAL_SNIFFER,PROJECT_CONF_H=\"project-conf.h\",NETSTACK_CONF_WITH_RIME
  c include: ../../Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/BSP/STM32F4xx_Nucleo;../../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library;../../../../../../../Middlewares/ST/Contiki_STM32_Library/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev;../../../../../../../Drivers/BSP/Components/;../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Inc;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core;../../../../../../../Middlewares/Third_Party/Contiki/core/sys;../../../../../../../Middlewares/Third_Party/Contiki/core/net;../../../../../../../Middlewares/Third_Party/Contiki/core/dev;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6;../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec;../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core/lib;../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack;../../../../../../../Projects/Multi/Applications/Contiki/Serial-sniffer/Inc;../../../../../../../Projects/Multi/Applications/Contiki/Serial-sniffer/Src/sniffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: ccm-star-packetbuf.c nullsec.c anti-replay.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: tcp-socket.c uip-debug.c uip-nameserver.c ip64-addr.c resolv.c tcpip.c psock.c uiplib.c uip-udp-packet.c uip-packetqueue.c uip-split.c udp-socket.c simple-udp.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: uip6.c uip-icmp6.c sicslowpan.c uip-nd6.c uip-ds6-route.c uip-ds6.c uip-ds6-nbr.c
  group Drivers/BSP/Components/SPIRIT1
    ../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Calibration.c SPIRIT_General.c SPIRIT_Timer.c SPIRIT_LinearFifo.c SPIRIT_PktStack.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_PktBasic.c SPIRIT_Commands.c SPIRIT_Radio.c SPIRIT_Qi.c SPIRIT_Management.c SPIRIT_Gpio.c SPIRIT_Aes.c SPIRIT_Irq.c SPIRIT_PktMbus.c SPIRIT_Types.c SPIRIT_PktCommon.c
  group Drivers/BSP/Components/S2LP/S2LP_Util
    ../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Middlewares/Contiki/core/sys
    ../../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c compower.c stimer.c rtimer.c autostart.c energest.c ctimer.c process.c etimer.c procinit.c timer.c
  group Middlewares/Contiki/apps/servreg-hack
    ../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack/: servreg-hack.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_shield_config.c radio_gpio.c radio_spi.c radio_timer.c radio_eeprom.c
  group Middlewares/Contiki/core/net
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/: packetbuf.c linkaddr.c netstack.c link-stats.c net-debug.c queuebuf.c nbr-table.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma_ex.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Example/User/sniffer
    ../../Src/sniffer/: framer-sniffer-802154.c serial-sniffer.c sniffer.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: frame802154.c frame802154e-ie.c mac.c nullrdc.c framer-802154.c nullrdc-noframer.c framer-nullmac.c nullmac.c csma.c nordc.c mac-sequence.c phase.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_spi.c radio_gpio.c radio_shield_config.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-of0.c rpl-icmp6.c rpl-dag-root.c rpl-ns.c rpl-dag.c rpl-nbr-policy.c rpl-mrhof.c rpl-timers.c rpl.c rpl-ext-header.c
  group Middlewares/Contiki/core/dev
    ../../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c
  group Drivers/BSP/Components/S2LP/S2LP_Library
    ../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_Gpio.c S2LP_Radio.c S2LP_Commands.c S2LP_Csma.c S2LP_Qi.c S2LP_Timer.c S2LP_Types.c S2LP_PktWMbus.c S2LP_PktStack.c S2LP_PktBasic.c S2LP_PacketHandler.c S2LP_Fifo.c S2LP_General.c
  group Middlewares/Contiki/core/lib
    ../../../../../../../Middlewares/Third_Party/Contiki/core/lib/: sensors.c memb.c random.c list.c
  group Example/User
    ../../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c cube_hal_f4.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: rtimer-arch.c contiki-st-radio-main.c watchdog.c clock.c console.c radio-arch.c node-id.c radio-driver.c
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: radio-sensor.c leds-arch.c button-sensor.c
target SPIRIT1_STM32F401RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: as above
  output: Serial-sniffer_f401
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: X_NUCLEO_IDS01A4,MCU_LOW_POWER=0,RADIO_LOW_POWER=0,PROJECT_CONF_H=1,STM32F401xE,USE_USART2,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,HSE_VALUE=84000000ul,USE_STDPERIPH_DRIVER,USE_SPIRIT1_DEFAULT,WITH_UIP6=1,IAR_ARM_CM3,VECT_TAB_FLASH,WITH_UIP,WITH_ASCII,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,NO_EEPROM,SPIRIT1_ST_SHIELD				,SPIRIT_MODULE
  c include: ../../Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/BSP/STM32F4xx_Nucleo;../../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library;../../../../../../../Middlewares/ST/Contiki_STM32_Library/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev;../../../../../../../Drivers/BSP/Components/;../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core;../../../../../../../Middlewares/Third_Party/Contiki/core/sys;../../../../../../../Middlewares/Third_Party/Contiki/core/net;../../../../../../../Middlewares/Third_Party/Contiki/core/dev;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6;../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec;../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core/lib;../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 4.3.0
